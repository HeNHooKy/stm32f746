# Keil uVision project application.uvprojx, settings and files
target STM32F746G-DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=24
  c include: ../../platform/os;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/stm32f7xx;../bsp/include/platform/stm32f7xx/CMSIS;../bsp/include/platform/stm32f7xx/STM32F7xx_HAL_Driver;../bsp/include;../bsp/include/vendor;../bsp/source/vendor/STM32746G-Discovery;../os/FreeRTOS8.2.0/Source/include;../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7;../../../middlewares/st/touchgfx/framework/include;../../generated/fonts/include;../../generated/gui_generated/include;../../generated/images/include;../../generated/texts/include;../../gui/include
  asm include: ../os/FreeRTOSV8.2.0/FreeRTOS/Source/include;../os/FreeRTOSV8.2.0/FreeRTOS/Source/portable/RVDS/ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../: main.cpp
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../bsp/source/platform/stm32f7xx/Keil/: startup_stm32f746xx.s
  group TouchGFXHAL
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
  group OS
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group HAL
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Lib
    ../../../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/dateboard_screen/: dateboardpresenter.cpp dateboardview.cpp
    ../../gui/src/containers/: dressmodul.cpp fon.cpp listtable.cpp msgbox.cpp pluszd.cpp services.cpp shoesmodul.cpp skin1.cpp
    ../../gui/src/common/: frontendapplication.cpp
    ../../gui/src/heatingboard_screen/: heatingboardpresenter.cpp heatingboardview.cpp
    ../../gui/src/mainboard_screen/: mainboardpresenter.cpp mainboardview.cpp
    ../../gui/src/manualboard_screen/: manualboardpresenter.cpp manualboardview.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/standartboard_screen/: standartboardpresenter.cpp standartboardview.cpp
    ../../gui/src/startboard_screen/: startboardpresenter.cpp startboardview.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_arial_14_4bpp_0.cpp font_arialbd_14_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_30_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_arial_14_4bpp.cpp kerning_arialbd_14_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_30_4bpp.cpp table_arial_14_4bpp.cpp table_arialbd_14_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_30_4bpp.cpp
    ../../generated/images/src/: bitmapdatabase.cpp blue_buttons_presed.cpp blue_buttons_round.cpp blue_buttons_round_m.cpp blue_buttons_round_m_pressed.cpp blue_check_buttons.cpp blue_check_buttons_check.cpp blue_check_buttons_check_.cpp blue_check_buttons_check_round.cpp blue_togglebars.cpp blue_togglebars2.cpp blue_togglebars3.cpp blue_togglebars4.cpp blue_togglebars_off.cpp blue_togglebars_off2.cpp blue_togglebars_on.cpp blue_togglebars_on2.cpp bulbgraphoff.cpp bulbgraphon.cpp calendar.cpp clear.cpp clic1.cpp clic2.cpp dark_icons_back_arrow.cpp dark_icons_back_arrow_passed.cpp dark_icons_next_arrow.cpp dark_icons_next_arrow_passed.cpp fon.cpp fon4.cpp fon6.cpp fon7.cpp icontime.cpp line.cpp ok_button.cpp ok_button_pressed.cpp thermometer_icon-icons.com_62485.cpp unikon_s.cpp warning.cpp warning_s.cpp
    ../../generated/images/src/__designer/: blue_slider_horizontal_small_indicators_slider_horizontal_small_round_knob.cpp blue_slider_horizontal_small_slider_horizontal_small_round_back.cpp blue_slider_horizontal_small_slider_horizontal_small_round_fill.cpp
    ../../generated/gui_generated/src/dateboard_screen/: dateboardviewbase.cpp
    ../../generated/gui_generated/src/containers/: dressmodulbase.cpp fonbase.cpp listtablebase.cpp msgboxbase.cpp pluszdbase.cpp servicesbase.cpp shoesmodulbase.cpp skin1base.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/gui_generated/src/heatingboard_screen/: heatingboardviewbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/mainboard_screen/: mainboardviewbase.cpp
    ../../generated/gui_generated/src/manualboard_screen/: manualboardviewbase.cpp
    ../../generated/gui_generated/src/standartboard_screen/: standartboardviewbase.cpp
    ../../generated/gui_generated/src/startboard_screen/: startboardviewbase.cpp
