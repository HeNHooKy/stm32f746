# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=24
  ICCARM.CCIncludePath2: ../../gui/include; ..\..\target\include; ..\..\platform\os; ../../generated/fonts/include; ../../generated/images/include; ../../generated/texts/include; ../../generated/gui_generated/include; ../../../Middlewares/ST/touchgfx/framework/include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\stm32f7xx; ..\bsp\include\platform\stm32f7xx\CMSIS; ..\bsp\include\platform\stm32f7xx\STM32F7xx_HAL_Driver; ..\bsp\include; ..\bsp\include\vendor; ..\bsp\source\vendor\STM32746G-Discovery; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ../../../Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR/touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_arial_13_4bpp_0.cpp Font_arial_14_4bpp_0.cpp Font_arial_14_4bpp_31.cpp Font_arial_22_4bpp_0.cpp Font_arial_22_4bpp_31.cpp Font_arialbd_14_4bpp_0.cpp Font_arialbd_14_4bpp_31.cpp Font_mriamc_23_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_30_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_arial_13_4bpp.cpp Kerning_arial_14_4bpp.cpp Kerning_arial_22_4bpp.cpp Kerning_arialbd_14_4bpp.cpp Kerning_mriamc_23_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_30_4bpp.cpp Table_arial_13_4bpp.cpp Table_arial_14_4bpp.cpp Table_arial_22_4bpp.cpp Table_arialbd_14_4bpp.cpp Table_mriamc_23_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_30_4bpp.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/containers
    ../../generated/gui_generated/src/containers/: addeventBase.cpp CustomListElementBase.cpp dressmodulBase.cpp fonBase.cpp MsgBoxBase.cpp shoesmodulBase.cpp skin1Base.cpp textBase.cpp
  group Application/generated/gui_generated/dateboard_screen
    ../../generated/gui_generated/src/dateboard_screen/: dateboardViewBase.cpp
  group Application/generated/gui_generated/heatingboard_screen
    ../../generated/gui_generated/src/heatingboard_screen/: heatingboardViewBase.cpp
  group Application/generated/gui_generated/mainboard_screen
    ../../generated/gui_generated/src/mainboard_screen/: mainboardViewBase.cpp
  group Application/generated/gui_generated/manualboard_screen
    ../../generated/gui_generated/src/manualboard_screen/: manualboardViewBase.cpp
  group Application/generated/gui_generated/standartboard_screen
    ../../generated/gui_generated/src/standartboard_screen/: standartboardViewBase.cpp
  group Application/generated/gui_generated/startboard_screen
    ../../generated/gui_generated/src/startboard_screen/: startboardViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: BitmapDatabase.cpp Blue_Buttons_presed.cpp Blue_Buttons_Round.cpp Blue_Buttons_Round_m.cpp Blue_Buttons_Round_m_pressed.cpp Blue_Check_buttons.cpp Blue_Check_buttons_Check.cpp Blue_Check_buttons_Check_.cpp Blue_Check_buttons_Check_Round.cpp Blue_Togglebars.cpp Blue_Togglebars2.cpp Blue_Togglebars3.cpp Blue_Togglebars4.cpp Blue_Togglebars6.cpp Blue_Togglebars7.cpp Blue_Togglebars8.cpp Blue_Togglebars9.cpp Blue_Togglebars_OFF.cpp Blue_Togglebars_OFF2.cpp Blue_Togglebars_ON.cpp Blue_Togglebars_ON2.cpp BulbgraphOff.cpp BulbgraphOn.cpp calendar.cpp clear.cpp clic1.cpp clic2.cpp Dark_Icons_Back_arrow.cpp Dark_Icons_Back_arrow_passed.cpp Dark_Icons_Next_arrow.cpp Dark_Icons_Next_arrow_passed.cpp fon.cpp fon4.cpp fon6.cpp fon7.cpp icontime.cpp line.cpp logo.cpp ok_button.cpp ok_button_pressed.cpp thermometer_icon-icons.com_62485.cpp unikon_s.cpp warning.cpp warning_s.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: Blue_Slider_Horizontal_Small_Indicators_slider_horizontal_small_round_knob.cpp Blue_Slider_Horizontal_Small_slider_horizontal_small_round_back.cpp Blue_Slider_Horizontal_Small_slider_horizontal_small_round_fill.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/containers
    ../../gui/src/containers/: addevent.cpp CustomListElement.cpp dressmodul.cpp fon.cpp MsgBox.cpp shoesmodul.cpp skin1.cpp text.cpp
  group Application/gui/dateboard_screen
    ../../gui/src/dateboard_screen/: dateboardPresenter.cpp dateboardView.cpp
  group Application/gui/heatingboard_screen
    ../../gui/src/heatingboard_screen/: heatingboardPresenter.cpp heatingboardView.cpp
  group Application/gui/mainboard_screen
    ../../gui/src/mainboard_screen/: mainboardPresenter.cpp mainboardView.cpp
  group Application/gui/manualboard_screen
    ../../gui/src/manualboard_screen/: manualboardPresenter.cpp manualboardView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/standartboard_screen
    ../../gui/src/standartboard_screen/: standartboardPresenter.cpp standartboardView.cpp
  group Application/gui/startboard_screen
    ../../gui/src/startboard_screen/: startboardPresenter.cpp startboardView.cpp
  group Application/main
    ../: main.cpp
  group Board/STM32F746G-DISCO
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F746G-DISCO/BSP
    ../bsp/source/bsp/: STM32F746GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F746G-DISCO/Vendor
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group MCU
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../bsp/source/platform/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
